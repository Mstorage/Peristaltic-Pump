# Keil uVision project Pump_Peristaltic_OpenSource.uvprojx, settings and files
target Pump_Peristaltic_OpenSource (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Pump_Peristaltic_OpenSource +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../Hardware;../Menu;../BMPdata
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c dma.c spi.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_spi.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group Hardware
    ../Hardware/: Key.h motor.c motor.h OLED_SPI.c OLED_SPI.h oledfont.h Flash_W25Q.c Flash_W25Q.h OLED_Gram.c OLED_DATE.c Key.c
  group Menu
    ../Menu/: menu.c menu.h UI.c UI.h
  group BMPdata
    ../BMPdata/: bitmap_HexData10041_10080.h bitmap_HexData10081_10120.h bitmap_HexData10121_10160.h bitmap_HexData10161_10200.h bitmap_HexData10201_10240.h bitmap_HexData10241_10280.h bitmap_HexData10281_10320.h bitmap_HexData10321_10360.h bitmap_HexData10361_10400.h bitmap_HexData10401_10440.h stepmotorDirection_HexData0_31.h
software components: CMSIS:CORE 4.3.0
